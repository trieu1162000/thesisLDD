# Keil uVision project AVG Program.uvprojx, settings and files
target AGV Test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AVG Program +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000
  c include: D:\AGVThesisProject;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx_Mylib\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c system_stm32f4xx.c system_timetick.c startup_stm32f40_41xxx.s stm32f4xx_it.c
  group STD Library
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c misc.c stm32f4xx_dma.c stm32f4xx_syscfg.c stm32f4xx_crc.c stm32f4xx_pwr.c stm32f4xx_adc.c stm32f4xx_spi.c
  group My Library
    ./STM32F4xx_Mylib/src/: PWM.c UART.c Encoder.c Bkpsram.c QTR_5RC.c tm_stm32f4_mfrc522.c tm_stm32f4_spi.c FuzzyLogic.c Interrupt_Timer.c I2C.c LCD_2004.c tm_stm32f4_gpio.c tm_stm32f4_adc.c PID.c
software components: CMSIS:CORE 5.3.0
